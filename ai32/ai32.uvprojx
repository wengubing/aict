# Keil uVision project ai32.uvprojx, settings and files
target Target 1 (5060750::V5.06 update 7 (build 960)::ARMCC)
  device: STM32F407VGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.17.1
  cpu: IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) IROM(0x8000000,0x100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(16000000) ELITTLE
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F407xx
  c include: User;CMSIS\Include;Device\Include
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT6: RAM 0x10000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group User
    User/: main.c
  group Device
    Device/Source/: startup_stm32f407xx.s system_stm32f4xx.c
