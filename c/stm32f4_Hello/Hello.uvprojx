# Keil uVision project Hello.uvprojx, settings and files
target STM32F103 Simulator (5060960::V5.06 update 7 (build 960)::.\ARM_Compiler_5.06u7)
  device: STM32F103RB STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00020000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Hello
  c flags: Optim=2 uC99=1 v6Lang=3 v6LangP=3
  c define: STM32F10X_MD
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Startup Files
    ./: startup_stm32f10x_md.s system_stm32f10x.c
  group Systemt Files
    ./: Retarget.c Serial.c
  group Source Files
    ./: Hello.c
  group Documentation
    ./: Abstract.txt
target STM32F103 Flash (ARM-ADS)
  device: STM32F103RB STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: as above
  output: Hello
  c flags: Optim=1 uC99=1 v6Lang=3 v6LangP=3
  c define: STM32F10X_MD
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
software components: CMSIS:CORE 5.6.0
